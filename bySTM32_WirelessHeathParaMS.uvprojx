# Keil uVision project bySTM32_WirelessHeathParaMS.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bySTM32_WirelessHeathParaMS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Library\inc;.\System;.\User;.\HeaderFiles;.\HardWare;.\Function
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ReadMe
    ./01ReadMe/: readme.txt
  group HeaderFiles
    ./Src/HeaderFiles/: general_definiens.h hard_ware.h USART.h ADC.h IIC.h OLED.h MAX30102.h
  group Protocal
    ./Src/Protocal/: USART.c ADC.c IIC.c
  group Function
    ./Src/Function/: delay.c delay.h Font.h Font.c menu.h menu.c hr_spo2_caculation.h hr_spo2_caculation.c
  group HardWare
    ./Src/HardWare/: hard_ware.c OLED.c MAX30102.c
  group User
    ./User/: stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h main.c
  group Library
    ./Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./Library/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group StartUp
    ./StartUp/: startup_stm32f10x_hd.s
  group System
    ./System/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
